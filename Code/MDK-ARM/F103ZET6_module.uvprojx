# Keil uVision project F103ZET6_module.uvprojx, settings and files
target F103ZET6_module (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103ZET6_module +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Module_Drivers;..\SmartDevice\Chip_abstr_layer(CAL);..\SmartDevice\Input;..\SmartDevice\Kernel_abstr_layer(KAL);..\SmartDevice\UnitTest;..\SmartDevice\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
    ./: startup_stm32f103xe.s
  group ModuleDriver
    ../Module_Drivers/: driver_Key.c driver_USART.c driver_LED.c driver_I2C.c driver_OLED.c Ring_buffer.c
  group KAL
    ../SmartDevice/Kernel_abstr_layer(KAL)/: KAL_GPIO_Key.c KAL_Time.c KAL_LED_Device.c
  group CAL
    ../SmartDevice/Chip_abstr_layer(CAL)/: CAL_GPIO_Key.c CAL_Time.c CAL_LED_Device.c
  group Input
    ../SmartDevice/Input/: GPIO_Key.c Input_buffer.c Input_system.c
  group Unit_test
    ../SmartDevice/UnitTest/: Input_test.c LED_test.c
  group Device
    ../SmartDevice/Device/: LED_Device.c
software components: CMSIS:CORE 4.3.0
